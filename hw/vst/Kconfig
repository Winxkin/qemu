## hw/vst/Kconfig
```kconfig
config VST_TEST_DEVICE
    bool
    default y

config VST_SHA3
    bool
    default y

config VST_DMAC
    bool
    default y
```
